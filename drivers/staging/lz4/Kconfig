## drivers/staging/lz4/Kconfig
```kconfig
config LZ4_COMPRESS
	tristate "LZ4 Compressor"
	default y

config LZ4_DECOMPRESS
	tristate "LZ4 Decompressor"
	default y
```
